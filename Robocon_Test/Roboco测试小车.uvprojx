# Keil uVision project Roboco测试小车.uvprojx, settings and files
target F103VE (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Roboco测试小车 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\代码;.\RTE\CMSIS;.\RTE\Device\STM32F103VE;.\RTE;.\Listings;.\Hardware;.\CORE;.\Hardware;.\STM32F10x_FWLib\inc;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Users
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h motion_control.c motor.c include.h
  group Hardware
    ./Hardware/: Robocon_board.c Robocon_TIM.c Robocon_ADC.c Robocon_Debug.c usart.c RCC_Conf.c DAC.c data.c nrf24l01.c spi.c system.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c
